## 1/hello/Kconfig
```kconfig
config HELLO
    tristate "First Android Driver"
	default m
	help
	This is the first android driver.
```
